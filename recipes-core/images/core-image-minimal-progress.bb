DESCRIPTION = "Progress Linux minimal image. This is a Linux image including LXQT and some basic tools "

LICENSE = "MIT"

inherit core-image-progress
