DEPENDS += " libxslt-native  docbook-xsl-stylesheets-native  xmlto-native" 
