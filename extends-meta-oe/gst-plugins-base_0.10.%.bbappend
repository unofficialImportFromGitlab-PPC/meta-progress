#DEPENDS_gst-plugins-base-libvisual += "libvisual"
DEPENDS += "libvisual"
