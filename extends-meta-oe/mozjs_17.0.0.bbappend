FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"  

SRC_URI += "file://0099-fix_powerpc64_pagesize.patch \
"            
