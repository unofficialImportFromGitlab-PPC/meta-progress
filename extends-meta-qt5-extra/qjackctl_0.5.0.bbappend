SRC_URI = " \
    	https://netcologne.dl.sourceforge.net/project/qjackctl/qjackctl%20%28attic%29/qjackctl-0.5.0.tar.gz \
	file://0001-find-native-qt-build-tools-by-configure-options-auto.patch \
"
