
FILES_${PN} += " \
        /usr/lib/qpdfview/libqpdfview_image.so \
        /usr/lib/qpdfview/libqpdfview_pdf.so \
        "
 
